# Keil uVision project Measuring Board.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab 3 Base Project
  c flags: Optim=1 wLevel=2
  c define: HSE_VALUE=8000000 USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\inc;.\Accelerometer_Drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/: main.c fputc_debug.c
  group drivers
    ./src/drivers/: lsm9ds1.c lsm9ds1.h
  group modules
    ./src/modules/: map.c map.h step.c step.h turn.c turn.h
  group sensors
    ./src/sensors/: acc.c acc.h gyro.c gyro.h
  group New Group
    ./src/: my_types.h
    ./src/interfaces/: cc2500.c cc2500.h cc2500_settings.h led_interface.c led_interface.h
    ./src/modules/: commands.h led_rotation_sm.c led_rotation_sm.h protocol_go_back_1.c protocol_go_back_1.h wireless_transmission_sm.c wireless_transmission_sm.h
    ./src/utils/: utils.c utils.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:CRC 1.3.0, Device:StdPeriph Drivers:CRYP 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DBGMCU 1.3.0, Device:StdPeriph Drivers:DCMI 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:FSMC 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:HASH 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
